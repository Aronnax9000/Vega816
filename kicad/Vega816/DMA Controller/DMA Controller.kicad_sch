File: kicad/Vega816/DMA Controller/DMA Controller.kicad_sch (KiCad schematic)
At the start: 53 parts, among them J2 Sysctl

Commit message: wrtolei
Other:
- moved on the sheet: D?, J2, J?, U?
